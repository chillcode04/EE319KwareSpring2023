# Keil uVision project Lab1.uvprojx, settings and files
target Lab1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s Lab1.s
  group Object
    ./: lab1grader.o pll.o timer3a.o uart.o
software components: CMSIS:CORE 5.4.0
